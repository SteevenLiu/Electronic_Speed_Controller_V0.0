# Keil uVision project DEMO_STM32F303CC.uvprojx, settings and files
target Target (ARM-ADS)
  device: STM32F303CCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DEMO_STM32F303CC +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\include;..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\Libraries\STM32F30x_I2C_CPAL_Driver\inc;..\User\include;..\Basic\nvic;..\Basic\delay;..\Basic\usart;..\Basic\hall;..\Basic\timer;..\Basic\flash;..\Basic\delay;..\Basic\adc;..\Basic\rcc;..\Basic\dma;..\App\ESC_StandardSCI_Protocol;..\App\ESC_Chopper;..\App\ESC_StateMachine;..\App\ESC_BLDCM_Hall;..\App\ESC_BLDCM_MISC;..\App\ESC_BLDCM_BASIC;..\App\ESC_Parameter;..\ISRs\ESC_ISRs_SysTick;..\ISRs\ESC_ISRs_TIM1;..\ISRs\ESC_ISRs_TIM8;..\ISRs\ESC_ISRs_USART1;..\ISRs\ESC_ISRs_ADC1_2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group CMSIS
    ../CMSIS/source/: system_stm32f30x.c
  group Startup
    ../Startup/: startup_stm32f30x.s
  group User
    ../User/source/: main.c stm32f30x_it.c
  group STM32F30x_StdPeriph_Driver
    ../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_rcc.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_flash.c stm32f30x_adc.c stm32f30x_dma.c
  group Basic
    ../Basic/usart/: usart.c
    ../Basic/flash/: flash.c
    ../Basic/timer/: timer.c
    ../Basic/nvic/: nvic.c
    ../Basic/hall/: hall.c
    ../Basic/adc/: adc.c
    ../Basic/delay/: delay.c
    ../Basic/dma/: dma.c
    ../Basic/rcc/: rcc.c
  group App
    ../App/ESC_Chopper/: ESC_Chopper.c
    ../App/ESC_StandardSCI_Protocol/: ESC_StandardSCI_Protocal.c
    ../App/ESC_StateMachine/: ESC_StateMachine_Main.c ESC_StateMachine_Control.c
    ../App/ESC_BLDCM_MISC/: ESC_BLDCM_MISC.c
    ../App/ESC_BLDCM_BASIC/: ESC_BLDCM_BASIC.c
    ../App/ESC_BLDCM_Hall/: ESC_BLDCM_Hall.c
    ../App/ESC_Parameter/: ESC_Parameter.c
  group ISRs
    ../ISRs/ESC_ISRs_SysTick/: ESC_ISRs_SysTick.c
    ../ISRs/ESC_ISRs_TIM1/: ESC_ISRs_TIM1.c
    ../ISRs/ESC_ISRs_TIM8/: ESC_ISRs_TIM8.c
    ../ISRs/ESC_ISRs_USART1/: ESC_ISRs_USART1.c
    ../ISRs/ESC_ISRs_ADC1_2/: ESC_ISRs_ADC1_2.c
